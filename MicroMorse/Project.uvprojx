# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  c include: ..\..\Microprocessors Lab\Keil - Embedded Programming on STM32L476VG\Thumb-2 Assembly\Lab 4 - Button Green LED\core_cm4_constants.s;..\..\Microprocessors Lab\Keil - Embedded Programming on STM32L476VG\Thumb-2 Assembly\Lab 4 - Button Green LED\stm32l476xx_constants.s;.\greenled_assembly.s
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./: main.c startup_stm32l476xx.s stm32l476xx.h LCD.c Pin_Connection.txt greenled_assembly.s
software components: CMSIS:CORE 6.0.0
